* EESchema Netlist Version 1.1 (Spice format) creation date: Mi 28 Aug 2013 11:26:05 CEST

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
R102  7 1 1.5k
D102  7 11 LED
D101  16 11 LED
R101  16 3 1.5k
K101  8 10 18 CONN_3
K102  11 4 22 XLR3
J102  19 11 15 JACK_2P
J101  13 11 2 JACK_2P
*Sheet Name:/USB Anschluss/
R1004  40 9 22
R1003  25 17 22
C1004  39 10 100n
C1003  32 10 100n
C1002  33 24 100n
C1001  23 24 100n
U1001  23 24 33 37 31 38 35 24 10 40 25 30 29 32 10 39 ADUM3160
R1002  34 35 22
R1001  36 38 22
L1001  41 28 36 34 ACM3225
D1001  26 24 27 41 24 28 SN65220
J1001  23 41 28 24 USB-BUCHSE
*Sheet Name:/USB Anschluss/Zusätzliche Beschaltung des Kopplers/
K1104  10 29 32 CONN_3
K1103  10 30 32 CONN_3
K1102  24 31 33 CONN_3
K1101  24 37 33 CONN_3
*Sheet Name:/Clip Detection/
C201  114 11 47u
R202  114 11 4.7k
R201  54 114 2k
C205  113 11 10n
R204  54 115 10k
C203  115 11 10u
U202  118 118 117 54 3 112 11 116 1 54 113 115 115 54 NE556
C202  118 11 10u
R203  54 118 10k
C204  117 11 10n
U201  112 6 114 11 114 14 116 54 LM393
*Sheet Name:/DC/DC/
U302  111 39 106 LM317
C304  106 10 0.1u
R305  111 10 750
R307  39 111 270
C306  111 10 10u
D306  111 39 1N4002
D304  39 106 1N4002
C308  39 10 1u
C309  54 11 1u
D305  54 106 1N4002
D307  110 54 1N4002
C307  110 11 10u
R308  54 110 270
R306  110 11 750
C305  106 11 0.1u
U303  110 54 106 LM317
U301  107 65 106 LM317
C301  106 11 0.1u
R301  107 11 2.2k
R303  65 107 240
C302  107 11 10u
D303  107 65 1N4002
D302  65 106 1N4002
C303  65 11 1u
R304  10 11 0
R302  109 10 0
D301  108 106 1N5817
P301  108 109 CONN_2
*Sheet Name:/Common GND/
C401  104 11 10u
C403  54 11 100n
C402  54 11 10u
R402  104 11 10k
R401  54 104 10k
R403  105 5 5.1k
U401  105 104 11 5 54 TL071
*Sheet Name:/Filter ADC/
S501  103 91 20 102 88 20 DPDT
R503  54 102 22k
C502  19 102 47u
R504  102 11 22k
R502  103 11 22k
C501  15 103 47u
R501  54 103 22k
C510  54 11 100n
C509  54 11 10u
U501  96 96 93 54 100 101 101 6 6 98 11 97 14 14 TL074
C504  100 5 680p
R508  99 100 9.1k
C506  99 101 6.8n
R506  88 99 1.1k
R510  101 97 1k
C508  97 5 6.8n
C507  98 5 6.8n
R509  96 98 1k
R505  91 92 1.1k
C505  92 96 6.8n
R507  92 93 9.1k
C503  93 5 680p
*Sheet Name:/Filter DAC/
R612  75 72 100
C612  72 13 10u
C611  76 2 10u
R611  74 76 100
R603  54 83 22k
R604  83 11 22k
C602  21 83 47u
C601  12 82 47u
R602  82 11 22k
R601  54 82 22k
C610  54 11 100n
C609  54 11 10u
U601  77 77 70 54 78 80 80 74 74 73 11 79 75 75 TL074
C604  78 5 680p
R608  81 78 9.1k
C606  81 80 6.8n
R606  83 81 1.1k
R610  80 79 1k
C608  79 5 6.8n
C607  73 5 6.8n
R609  77 73 1k
R605  82 71 1.1k
C605  71 77 6.8n
R607  71 70 9.1k
C603  70 5 680p
*Sheet Name:/Mikrofonverstärker/
R704  11 64 4.7k
R706  64 54 4.7k
SW701  65 68 11 SWITCH_INV
C703  54 11 10u
C704  54 11 100n
RV701  66 66 67 50k
R707  63 67 47
R705  69 54 4.7k
R703  11 69 4.7k
C702  22 64 47u
C701  4 69 47u
R702  4 68 680
R701  22 68 680
U701  66 64 69 11 5 20 54 63 AD620
*Sheet Name:/Audio Codec mit USB Schnittstelle/
C809  6 55 4.7u
C808  14 48 4.7u
D801  54 51 DIODESCH
C805  10 49 1uF
R804  49 39 2.2
C801  51 11 10uF
C802  50 10 1uF
C803  53 10 1uF
C804  43 10 1uF
C806  52 11 10uF
C807  58 10 1uF
R807  61 44 1.5k
R806  45 44 1.5k
R805  60 44 1.5k
P801  47 60 59 45 46 61 CONN_3X2
R801  9 58 1.5k
R803  9 56 22
R802  17 57 22
U801  56 57 49 10 47 59 46 58 58 51 11 48 55 52 21 12 50 11 53 42 62 11 43 18 8 10 58 44 PCM2906C
*Sheet Name:/Audio Codec mit USB Schnittstelle/PCM2906C Crystal/
R901  42 62 1M
C901  42 10 C
C902  62 10 C
X901  42 62 12MHz

.end
